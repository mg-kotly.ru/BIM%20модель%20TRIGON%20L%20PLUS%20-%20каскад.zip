Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2021-11-08T15:36:19
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20180216_1515(x64) - Exporter 19.0.0.405 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Nov 08 15:36:19 2021 * Host: SALEXAN-RO-DE * Database: C:\Users\Salexan\AppData\Local\Temp\{203778DB-C4C0-482F-97C2-EF5436BCC1E1}\ifc * Database version: 5507 * Database creation date: Mon Nov 08 15:36:17 2021 * Schema: IFC4 * Model: DataRepository.ifc * Model creation date: Mon Nov 08 15:36:17 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Nov 08 15:36:17 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 23, 13, 199999; RefLongitude: -71, -14, -31, -199999; RefElevation: 0 mm
Dimensions - S4R_Use_nominal_diameter: yes
Identity Data - Design Option: Main Model
Other - Category: Project Information; Client Name: Client Name; Project Address: Enter address here; Project Issue Date: Project Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - Reference: Project Information; NumberOfStoreys: 1
Dimensions - S4R_Use_nominal_diameter: yes
Identity Data - Design Option: Main Model
Other - Category: Project Information; Client Name: Client Name; Project Address: Enter address here; Project Issue Date: Project Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey, F00
LongName: F00; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: Floor Level
Graphics(Type) - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol: GE_tag_level_floor_MEPcontent: standard; Symbol at End 1 Default: yes; Symbol at End 2 Default: yes
Constraints(Type) - Elevation Base: Project Base Point
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: F00; Structural: no
Other - Category: Levels; Family: Level: Floor Level; Family and Type: Level: Floor Level; Type: Level: Floor Level; Type Id: Level: Floor Level

# IfcBoiler: BACK TO BACK_2 BOILERS_140kW_DN 100, HC_Boiler_MEPcontent_Elco_TRIGON L PLUS CASCADE_BACK TO BACK_2 BOILERS_140kW_DN 100_INT-EN:BACK TO BACK_2 BOILERS_140kW_DN 100:1671476
In: F00
Type - Material: Color RGB 245-197-044, Color RGB 023-097-171, Color RGB 178-000-000, Color RGB 127-127-127
Type - Dimensions - Depth: 700 mm; Drain Diameter: 32 mm; Flue Gas Diameter: 100 mm; Gas Diameter: 65 mm; Gas Nominal Diameter: 65 mm; Gas Outer Diameter: 76.1 mm; Height: 1848 mm; Hydronic Nominal Diameter: 100 mm; Hydronic Outer Diameter: 114.3 mm; Hydronic Return Diameter: 100 mm; Hydronic Supply Diameter: 100 mm; Supply Air Diameter: 100 mm; Use Nominal Diameter: yes; Width: 1801 mm
Type - Electrical - Electrical Connection: 230 V; Frequency: 50 Hz; IP Class: IPX4D; Mains Connection Fuse: 0 A; Power Consumption Boiler max ErP (Incl. Pump): 418 W; Power Consumption Boiler min ErP (Incl. Pump): 71 W; Voltage: 230 V
Type - General - CE Certification Code: 0063CT3449; Maximum Gas Pressure: 5750 Pa; Min Gas Pressure H-gas: 1700 Pa; Min Gas Pressure L-gas: 2000 Pa; Min Gas Pressure LPG (mbar): 25-35; Minimum Heat Input Hi min: 14900 W; Minimum Heat Output at 40/30ºC: 16000 W; Minimum Heat Output at 50/30ºC: 15900 W; Minimum Heat Output at 75-60ºC: 14600 W; Minimum Heat Output at 80-60ºC: 14600 W; Modulation: 0; Noise Level (dB(A)): 0; Nominal Heat Input Hi max: 266400 W; Nominal Heat Output at 40/30ºC: 284700 W; Nominal Heat Output at 50/30ºC: 284300 W; Nominal Heat Output at 75-60ºC: 259700 W; Nominal Heat Output at 80-60ºC: 261000 W; Sound Pressure Level (dB(A)): 0; Weight (empty): 254
Type - Identity Data - Article Description: Cascade floor standing - 2_2x140 - Back to Back; Article Type: BACK TO BACK_2 BOILERS_140kW_DN 100; Base Family Version: 12.32; Content Supplier URL: www.MEPcontent.com; Copyright: © Trimble Europe BV; Custom: no; Description: Cascade floor standing - 2_2x140 - Back to Back; EMCS Version: 4.0; ETIM Article Class: EC011755; Family Version: 12.09; GTIN: TR_PLUS_B2B_2x140; Manufacturer: Elco; Manufacturer URL: http://www.elco.net/; MEPcontent Class: BOILER; Model: BACK TO BACK_2 BOILERS_140kW_DN 100; OmniClass Number: 23.75.10.11.14; OmniClass Title: Hot Water Heat Generators; Product Line: Elco; Revit Version: 2019; Type Name: BACK TO BACK_2 BOILERS_140kW_DN 100; URL: https://mep.trimble.com; Watermarked By: https://mep.trimble.com
Type - Materials and Finishes - Blue: Color RGB 023-097-171; Grey: Color RGB 127-127-127; Red: Color RGB 178-000-000; Yellow: Color RGB 245-197-044
Type - Mechanical - Hydraulic Resistance at Nominal Water Flow: 32570 Pa; Hydraulic Resistance at Nominal Water Flow (dT 25K): 20880 Pa; Max. Condensate (full load @ 40/30ºC, 20ºC ambient, G20): 0.000007 m3/s; Max. Permissible Flue Resistance max: 400 Pa; Maximum Temperature Setpoint: 90 kg/K/s3; Maximum Water Temperature (High Limit Thermostat): 95 kg/K/s3; Nominal Power 50-30°C: 0; Nominal Power 80-60°C: 0; Nominal Water Flow at dT=20K: 0.00311111 m3/s; Nominal Water Flow at dT=25K: 0.00249722 m3/s; NOx Class: 6; Tap Capacity at 60°C: 0 m3/s; Volume: 0 m3; Water Pressure max: 600000 Pa; Water Pressure min: 70000 Pa; Water Volume: 0.0336 m3; ΔT max (K): 30
Type - Other - Category: Mechanical Equipment; Family Name: HC_Boiler_MEPcontent_Elco_TRIGON L PLUS CASCADE_BACK TO BACK_2 BOILERS_140kW_DN 100_INT-EN; First Ventilation Position: 370 mm; Gas Position: 240 mm; Header Depth: 178 mm; Header Length: 1061 mm; Hydronic Pipe Depth: 178 mm; Hydronic Supply Position: 1790.85 mm; Length Boilers: 740 mm; Number of Boilers: 2; Number of Poles: 3; Radius: 57.15 mm; Ventilation Connectors Depth: 243 mm
Pset_ElectricalDeviceCommon - NumberOfPoles: 3
Pset_ManufacturerTypeInformation - Manufacturer: Elco
Constraints - Offset: 0 mm
Dimensions - Area: 7.86338 m2; Volume: 0.465822 m3
Electrical - Loads - Power: 418 W
Identity Data - Design Option: Main Model; Mark: 4
Mechanical - System Classification: Supply Air,Power,Other,Hydronic Supply,Hydronic Return,Other,Sanitary,Hydronic Return,Other,Supply Air,Power,Sanitary
Mechanical - Flow - Drain Fixture Units 1: 0; Drain Fixture Units 2: 0; Flue Gas Flow 1: 0 m3/s; Flue Gas Flow 2: 0 m3/s; Gas Flow: 0 m3/s; Hydronic Return Flow: 0 m3/s; Hydronic Supply Flow: 0 m3/s; Supply Air Flow 1: 0 m3/s; Supply Air Flow 2: 0 m3/s
Other - Counter Flange Left: yes; Counter Flange Right: no; Family: HC_Boiler_MEPcontent_Elco_TRIGON L PLUS CASCADE_BACK TO BACK_2 BOILERS_140kW_DN 100_INT-EN: BACK TO BACK_2 BOILERS_140kW_DN 100; Family and Type: HC_Boiler_MEPcontent_Elco_TRIGON L PLUS CASCADE_BACK TO BACK_2 BOILERS_140kW_DN 100_INT-EN: BACK TO BACK_2 BOILERS_140kW_DN 100; Gas Pipe Length: 710 mm; Header Position Left Safe: 0 mm; Header Position Right Safe: 1200 mm; Hydronic Return Position Left: 178 mm; Hydronic Return Position Right: 328 mm; Left Hydronic Return Height: 195 mm; Left Hydronic Supply Height: 755 mm; Reference Line Length Left: 1460 mm; Reference Line Length Right: 355 mm; Right Hydronic Return Height: 1588 mm; Right Hydronic Supply Height: 1743 mm; Type: HC_Boiler_MEPcontent_Elco_TRIGON L PLUS CASCADE_BACK TO BACK_2 BOILERS_140kW_DN 100_INT-EN: BACK TO BACK_2 BOILERS_140kW_DN 100; Type Id: HC_Boiler_MEPcontent_Elco_TRIGON L PLUS CASCADE_BACK TO BACK_2 BOILERS_140kW_DN 100_INT-EN: BACK TO BACK_2 BOILERS_140kW_DN 100
Phasing - Phase Created: 4. Plan over 10 years
Visibility - Counter Flange: no; Header Position Left: yes; Header Position Right: no

# IfcBoiler: TRIGON L PLUS 140 (2)
In: F00
Type - Material: Color RGB 049-049-049, Color RGB 216-216-216, Color RAL 9016, Color RGB 172-184-196
Type - Dimensions - Use Nominal Diameter: yes; Depth: 590 mm; Drain Diameter: 32 mm; Flue Gas Diameter: 100 mm; Gas Diameter: 28.6 mm; Height: 1050 mm; Hydronic Return Diameter: 45 mm; Hydronic Supply Diameter: 45 mm; Supply Air Diameter: 100 mm; Width: 690 mm
Type - Electrical - Electrical Connection: 230 V; Frequency: 50 Hz; Hertz: 50 Hz; IP Class: IPX4D; Mains Connection Fuse: 6.3 A; Phase: 1; Power Consumption Boiler max ErP (Incl. Pump): 418 W; Power Consumption Boiler min ErP (Incl. Pump): 71 W; Voltage: 230 V
Type - General - CE Certification Code: 0063CT3449; Maximum Gas Pressure: 5750 Pa; Min Gas Pressure H-gas: 1700 Pa; Min Gas Pressure L-gas: 2000 Pa; Min Gas Pressure LPG (mbar): 25-35; Minimum Heat Input Hi min: 14900 W; Minimum Heat Output at 40/30ºC: 16000 W; Minimum Heat Output at 50/30ºC: 15900 W; Minimum Heat Output at 75-60ºC: 14600 W; Minimum Heat Output at 80-60ºC: 14700 W; Modulation: 9; Noise Level (dB(A)): 70.3; Nominal Heat Input Hi max: 133200 W; Nominal Heat Output at 40/30ºC: 142400 W; Nominal Heat Output at 50/30ºC: 142200 W; Nominal Heat Output at 75-60ºC: 129900 W; Nominal Heat Output at 80-60ºC: 130600 W; Sound Pressure Level (dB(A)): 59.3; Weight (empty): 127
Type - Identity Data - Custom: no; Article Description: Boiler 140kW floor standing; Article Type: TRIGON L PLUS 140; Base Family Version: 12.15; Content Supplier URL: www.MEPcontent.com; Copyright: © Stabiplan International BV; Description: Boiler 140kW floor standing; EMCS Version: 4.0; ETIM Article Class: EC011396; Family Version: 12.09; Manufacturer: Elco; Manufacturer URL: http://www.elco.net/; MEPcontent Class: BOILER; Model: TRIGON L PLUS 140; OmniClass Number: 23.75.10.11.14; OmniClass Title: Hot Water Heat Generators; Product Line: Elco; Revit Version: 2017; Type Name: TRIGON L PLUS 140; URL: www.stabiplan.com; Watermarked By: www.stabiplan.com
Type - Materials and Finishes - Black: Color RGB 049-049-049; Light Grey: Color RGB 172-184-196; Light White: Color RAL 9016; White: Color RGB 216-216-216
Type - Mechanical - Nominal Power 50-30°C: 0; Nominal Power 80-60°C: 0; Hydraulic Resistance at Nominal Water Flow: 32570 Pa; Hydraulic Resistance at Nominal Water Flow (dT 25K): 20880 Pa; Max. Condensate (full load @ 40/30ºC, 20ºC ambient, G20): 0.0000035 m3/s; Max. Permissible Flue Resistance max: 200 Pa; Maximum Available Head for System: 6600 Pa; Maximum Temperature Setpoint: 90 kg/K/s3; Maximum Water Temperature (High Limit Thermostat): 95 kg/K/s3; Nominal Water Flow at dT=20K: 0.00158333 m3/s; Nominal Water Flow at dT=25K: 0.00125 m3/s; NOx Class: 6; Tap Capacity at 60°C: 0 m3/s; Total Head at Nominal Flow: 39100 Pa; Volume: 0 m3; Water Pressure max: 600000 Pa; Water Pressure min: 70000 Pa; Water Volume: 0.0168 m3; ΔT max (K): 30
Type - Other - Category: Mechanical Equipment; Family Name: HC_Boiler_MEPcontent_Elco_TRIGON L PLUS 140_INT-EN_Shared
Pset_ManufacturerTypeInformation - Manufacturer: Elco
Constraints - Offset: 0 mm; Moves With Nearby Elements: no
Dimensions - Area: 1.84131 m2; Legs Height: 50 mm; Volume: 0.440182 m3
Electrical - Loads - Power: 418 W
Other - Family: HC_Boiler_MEPcontent_Elco_TRIGON L PLUS 140_INT-EN_Shared: TRIGON L PLUS 140; Family and Type: HC_Boiler_MEPcontent_Elco_TRIGON L PLUS 140_INT-EN_Shared: TRIGON L PLUS 140; Legs Height 2 Safe: 30 mm; Legs Height Safe: 50 mm; Type: HC_Boiler_MEPcontent_Elco_TRIGON L PLUS 140_INT-EN_Shared: TRIGON L PLUS 140; Type Id: HC_Boiler_MEPcontent_Elco_TRIGON L PLUS 140_INT-EN_Shared: TRIGON L PLUS 140
Phasing - Phase Created: 4. Plan over 10 years
Name (HC_Boiler_MEPcontent_Elco_TRIGON L PLUS 140_INT-EN_Shared:TRIGON L PLUS 140:...) | Mark
1671477 | 5 | Identity Data - Design Option: Main Model
1671478 | 6
