Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2023-04-26T11:22:34
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190327_2315(x64) - Exporter 20.0.0.377 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Apr 26 11:22:34 2023 * Host: GVIZITI-RO-LE * Database: C:\Users\gviziti\AppData\Local\Temp\034012c7-b6c1-4297-a8ad-59cf91ee4df1\fda8a030-6b7d-4fd0-b991-ca9f2d17069e\ifc * Database version: 5507 * Database creation date: Wed Apr 26 11:21:58 2023 * Schema: IFC4 * Model: DataRepository.ifc * Model creation date: Wed Apr 26 11:21:59 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Apr 26 11:21:59 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm
Other - Category: Project Information

# IfcBuilding
Pset_BuildingCommon - Reference: Project Information; NumberOfStoreys: 1
Other - Category: Project Information

# IfcBuildingStorey: Level:Level 1, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: Level 1
Pset_BuildingStoreyCommon - Reference: Level 1
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: Level 1; Family and Type: Level: Level 1; Type: Level: Level 1; Type Id: Level: Level 1
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcBoiler: IN LINE_4 BOILERS_170kW_DN 100, HC_Boiler_MEPcontent_Elco_TRIGON L PLUS CASCADE_IN LINE_4 BOILERS_170kW_DN 100_INT-EN:IN LINE_4 BOILERS_170kW_DN 100:330802
In: Level 1
Type - Material: Color RGB 127-127-127, Color RGB 245-197-044, Color RGB 178-000-000, Color RGB 023-097-171
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - Depth: 1199 mm; Drain Diameter: 32 mm; Flue Gas Diameter: 130 mm; Gas Diameter: 65 mm; Gas Nominal Diameter: 65 mm; Gas Outer Diameter: 76.1 mm; Height: 1848 mm; Hydronic Nominal Diameter: 100 mm; Hydronic Outer Diameter: 114.3 mm; Hydronic Return Diameter: 100 mm; Hydronic Supply Diameter: 100 mm; Supply Air Diameter: 130 mm; Use Nominal Diameter: yes; Width: 3902 mm
Type - Electrical - Electrical Connection: 230 V; Frequency: 50 Hz; IP Class: IPX4D; Mains Connection Fuse: 0 A; Power Consumption Boiler max ErP (Incl. Pump): 464 W; Power Consumption Boiler min ErP (Incl. Pump): 109 W; Voltage: 230 V
Type - General - CE Certification Code: 0063CT3449; Maximum Gas Pressure: 5750 Pa; Min Gas Pressure H-gas: 1700 Pa; Min Gas Pressure L-gas: 2000 Pa; Min Gas Pressure LPG (mbar): 25-35; Minimum Heat Input Hi min: 14900 W; Minimum Heat Output at 40/30ºC: 16100 W; Minimum Heat Output at 50/30ºC: 16000 W; Minimum Heat Output at 75-60ºC: 14600 W; Minimum Heat Output at 80-60ºC: 14600 W; Modulation: 0; Noise Level (dB(A)): 0; Nominal Heat Input Hi max: 635200 W; Nominal Heat Output at 40/30ºC: 683400 W; Nominal Heat Output at 50/30ºC: 681600 W; Nominal Heat Output at 75-60ºC: 617400 W; Nominal Heat Output at 80-60ºC: 621800 W; Sound Pressure Level (dB(A)): 0; Weight (empty): 528
Type - Identity Data - Article Description: Cascade floor standing - 4_4x170 - In Line; Article Type: IN LINE_4 BOILERS_170kW_DN 100; Base Family Version: 23.05; Content Supplier URL: www.MEPcontent.com; Copyright: © Trimble Europe BV; Custom: no; Description: Cascade floor standing - 4_4x170 - In Line; EMCS Version: 4.0; ETIM Article Class: EC011755; Family Version: 12.09; Manufacturer: Elco; Manufacturer URL: http://www.elco.net/; MEPcontent Class: BOILER; Model: IN LINE_4 BOILERS_170kW_DN 100; OmniClass Number: 23.75.10.11.14; OmniClass Title: Hot Water Heat Generators; Product Line: Elco; Revit Version: 2020; Type Name: IN LINE_4 BOILERS_170kW_DN 100; URL: https://mep.trimble.com; Watermarked By: https://mep.trimble.com
Type - Materials and Finishes - Blue: Color RGB 023-097-171; Grey: Color RGB 127-127-127; Red: Color RGB 178-000-000; Yellow: Color RGB 245-197-044
Type - Mechanical - Hydraulic Resistance at Nominal Water Flow: 34420 Pa; Hydraulic Resistance at Nominal Water Flow (dT 25K): 22030 Pa; Max. Condensate (full load @ 40/30ºC, 20ºC ambient, G20): 0.000647436 m3/s; Max. Permissible Flue Resistance max: 860 Pa; Maximum Temperature Setpoint: 90 kg/K/s3; Maximum Water Temperature (High Limit Thermostat): 95 kg/K/s3; Nominal Power 50-30°C: 0; Nominal Power 80-60°C: 0; Nominal Water Flow at dT=20K: 0.262898 m3/s; Nominal Water Flow at dT=25K: 0.210318 m3/s; NOx Class: 6; Tap Capacity at 60°C: 0 m3/s; Volume: 0 m3; Water Pressure max: 600000 Pa; Water Pressure min: 70000 Pa; Water Volume: 0.0852 m3; ΔT max (K): 30
Type - Other - Category: Mechanical Equipment; Distance Boilers: 700 mm; Family Name: HC_Boiler_MEPcontent_Elco_TRIGON L PLUS CASCADE_IN LINE_4 BOILERS_170kW_DN 100_INT-EN; First Ventilation Position: 370 mm; Gas Position: 240 mm; Header Depth: 178 mm; Header Length: 1061 mm; Hydronic Pipe Depth: 178 mm; Hydronic Supply Position: 1790.85 mm; Length Boilers: 2841 mm; Number of Boilers: 4; Number of Poles: 5; Radius: 57.15 mm; Ventilation Connectors Depth: 243 mm
Type - Pset_BoilerTypeCommon - Reference: IN LINE_4 BOILERS_170kW_DN 100
Type - Pset_ElectricalDeviceCommon - NumberOfPoles: 5
Type - Pset_EnvironmentalImpactIndicators - Reference: IN LINE_4 BOILERS_170kW_DN 100
Type - Pset_ManufacturerTypeInformation - Manufacturer: Elco
Pset_BoilerTypeCommon - sets with these values: 2
Constraints - Elevation from Level: 0 mm; Offset from Host: 0 mm
Dimensions - Area: 11.2495 m2; Volume: 0.557612 m3
Electrical - Power: 464 W
Identity Data - Mark: 1
Mechanical - System Classification: Supply Air,Power,Other,Hydronic Supply,Hydronic Return,Other,Sanitary,Hydronic Return
Mechanical - Flow - Drain Fixture Units 1: 0; Drain Fixture Units 2: 0; Drain Fixture Units 3: 0; Drain Fixture Units 4: 0; Flue Gas Flow 1: 0 m3/s; Flue Gas Flow 2: 0 m3/s; Flue Gas Flow 3: 0 m3/s; Flue Gas Flow 4: 0 m3/s; Gas Flow: 0 m3/s; Hydronic Return Flow: 0 m3/s; Hydronic Supply Flow: 0 m3/s; Supply Air Flow 1: 0 m3/s; Supply Air Flow 2: 0 m3/s; Supply Air Flow 3: 0 m3/s; Supply Air Flow 4: 0 m3/s
Other - Counter Flange Left: yes; Counter Flange Right: no; Family: HC_Boiler_MEPcontent_Elco_TRIGON L PLUS CASCADE_IN LINE_4 BOILERS_170kW_DN 100_INT-EN: IN LINE_4 BOILERS_170kW_DN 100; Family and Type: HC_Boiler_MEPcontent_Elco_TRIGON L PLUS CASCADE_IN LINE_4 BOILERS_170kW_DN 100_INT-EN: IN LINE_4 BOILERS_170kW_DN 100; Gas Pipe Length: 2811 mm; Header Position Left Safe: 0 mm; Header Position Right Safe: 1200 mm; Hydronic Return Position Left: 178 mm; Hydronic Return Position Right: 328 mm; Left Hydronic Return Height: 195 mm; Left Hydronic Supply Height: 755 mm; Reference Line Length Left: 2510.5 mm; Reference Line Length Right: 1405.5 mm; Right Hydronic Return Height: 1588 mm; Right Hydronic Supply Height: 1743 mm; Type: HC_Boiler_MEPcontent_Elco_TRIGON L PLUS CASCADE_IN LINE_4 BOILERS_170kW_DN 100_INT-EN: IN LINE_4 BOILERS_170kW_DN 100; Type Id: HC_Boiler_MEPcontent_Elco_TRIGON L PLUS CASCADE_IN LINE_4 BOILERS_170kW_DN 100_INT-EN: IN LINE_4 BOILERS_170kW_DN 100
Phasing - Phase Created: New Construction
Visibility - Counter Flange: no; Header Position Left: yes; Header Position Right: no

# IfcBoiler: TRIGON L PLUS 170 (4)
In: Level 1
Type - PredefinedType: WATER; Material: Color RGB 049-049-049, Color RGB 216-216-216, Color RAL 9016, Color RGB 172-184-196
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - Use Nominal Diameter: yes; Depth: 670 mm; Drain Diameter: 32 mm; Flue Gas Diameter: 130 mm; Gas Diameter: 28.6 mm; Height: 1050 mm; Hydronic Return Diameter: 45 mm; Hydronic Supply Diameter: 45 mm; Supply Air Diameter: 130 mm; Width: 690 mm
Type - Electrical - Electrical Connection: 230 V; Frequency: 50 Hz; Hertz: 50 Hz; IP Class: IPX4D; Mains Connection Fuse: 6.3 A; Phase: 1; Power Consumption Boiler max ErP (Incl. Pump): 464 W; Power Consumption Boiler min ErP (Incl. Pump): 109 W; Voltage: 230 V
Type - General - CE Certification Code: 0063CT3449; Maximum Gas Pressure: 5750 Pa; Min Gas Pressure H-gas: 1700 Pa; Min Gas Pressure L-gas: 2000 Pa; Min Gas Pressure LPG (mbar): 25-35; Minimum Heat Input Hi min: 14900 W; Minimum Heat Output at 40/30ºC: 16100 W; Minimum Heat Output at 50/30ºC: 16000 W; Minimum Heat Output at 75-60ºC: 14600 W; Minimum Heat Output at 80-60ºC: 14700 W; Modulation: 11; Noise Level (dB(A)): 67; Nominal Heat Input Hi max: 158800 W; Nominal Heat Output at 40/30ºC: 170900 W; Nominal Heat Output at 50/30ºC: 170400 W; Nominal Heat Output at 75-60ºC: 154400 W; Nominal Heat Output at 80-60ºC: 155500 W; Sound Pressure Level (dB(A)): 56; Weight (empty): 132
Type - Identity Data - Custom: no; Article Description: Boiler 170kW floor standing; Article Type: TRIGON L PLUS 170; Base Family Version: 23.05; Content Supplier URL: www.MEPcontent.com; Copyright: © Trimble Europe BV; Description: Boiler 170kW floor standing; EMCS Version: 4.0; ETIM Article Class: EC011396; Family Version: 12.09; Manufacturer: Elco; Manufacturer URL: http://www.elco.net/; MEPcontent Class: BOILER; Model: TRIGON L PLUS 170; OmniClass Number: 23.75.10.11.14; OmniClass Title: Hot Water Heat Generators; Product Line: Elco; Revit Version: 2020; Type Name: TRIGON L PLUS 170; URL: https://mep.trimble.com; Watermarked By: https://mep.trimble.com
Type - Materials and Finishes - Black: Color RGB 049-049-049; Light Grey: Color RGB 172-184-196; Light White: Color RAL 9016; White: Color RGB 216-216-216
Type - Mechanical - Nominal Power 50-30°C: 0; Nominal Power 80-60°C: 0; Hydraulic Resistance at Nominal Water Flow: 34420 Pa; Hydraulic Resistance at Nominal Water Flow (dT 25K): 22030 Pa; Max. Condensate (full load @ 40/30ºC, 20ºC ambient, G20): 0.000161859 m3/s; Max. Permissible Flue Resistance max: 215 Pa; Maximum Available Head for System: 8100 Pa; Maximum Temperature Setpoint: 90 kg/K/s3; Maximum Water Temperature (High Limit Thermostat): 95 kg/K/s3; Nominal Water Flow at dT=20K: 0.0667055 m3/s; Nominal Water Flow at dT=25K: 0.052972 m3/s; NOx Class: 6; Tap Capacity at 60°C: 0 m3/s; Total Head at Nominal Flow: 42500 Pa; Volume: 0 m3; Water Pressure max: 600000 Pa; Water Pressure min: 70000 Pa; Water Volume: 0.0213 m3; ΔT max (K): 30
Type - Other - Category: Mechanical Equipment; Family Name: HC_Boiler_MEPcontent_Elco_TRIGON L PLUS 170_INT-EN_Shared
Type - Pset_BoilerTypeCommon - Reference: TRIGON L PLUS 170
Type - Pset_EnvironmentalImpactIndicators - Reference: TRIGON L PLUS 170
Type - Pset_ManufacturerTypeInformation - Manufacturer: Elco
Pset_BoilerTypeCommon - sets with these values: 2
Constraints - Elevation from Level: 0 mm; Offset from Host: 0 mm; Moves With Nearby Elements: no
Dimensions - Area: 1.98824 m2; Legs Height: 50 mm; Volume: 0.499031 m3
Electrical - Power: 464 W
Other - Family: HC_Boiler_MEPcontent_Elco_TRIGON L PLUS 170_INT-EN_Shared: TRIGON L PLUS 170; Family and Type: HC_Boiler_MEPcontent_Elco_TRIGON L PLUS 170_INT-EN_Shared: TRIGON L PLUS 170; Legs Height 2 Safe: 30 mm; Legs Height Safe: 50 mm; Type: HC_Boiler_MEPcontent_Elco_TRIGON L PLUS 170_INT-EN_Shared: TRIGON L PLUS 170; Type Id: HC_Boiler_MEPcontent_Elco_TRIGON L PLUS 170_INT-EN_Shared: TRIGON L PLUS 170
Phasing - Phase Created: New Construction
Name (HC_Boiler_MEPcontent_Elco_TRIGON L PLUS 170_INT-EN_Shared:TRIGON L PLUS 170:...) | Mark
330821 | 2
330822 | 3
330823 | 4
330824 | 5

# IfcDistributionPort (22)
Description: Flow
Name | FlowDirection
10 x Port_330802 | SOURCEANDSINK
8 x Port_330802 | SINK
4 x Port_330802 | SOURCE
